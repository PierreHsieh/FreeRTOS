# Keil uVision project STM32F411_FreeRTOS_Try.uvprojx, settings and files
target STM32F411_FreeRTOS_Try (ARM-ADS)
  device: STM32F411RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F411_FreeRTOS_Try
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Inc;      ../Drivers/STM32F4xx_HAL_Driver/Inc;      ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;      ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;      ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;      ../Middlewares/Third_Party/FreeRTOS/Source/include;      ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;      ../Drivers/CMSIS/Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: timers.c tasks.c croutine.c list.c queue.c event_groups.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_cortex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: freertos.c stm32f4xx_hal_msp.c stm32f4xx_it.c main.c
software components: CMSIS:CORE 4.3.0
